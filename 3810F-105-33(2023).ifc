Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T19:00:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 19:00:01 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\5bbce92c-35a3-4029-bf56-e717752147ea\ifc * Database version: 5507 * Database creation date: Fri Apr 26 19:00:01 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 19:00:01 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 19:00:01 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 3810F-105-33 Washbasin faucet, 3810F-105-33(2023):3810F-105-33 Washbasin faucet:63166
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass - Matt black
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 156.697 mm; NominalHeight: 142.775 mm; NominalWidth: 48.4712 mm
Type - General - Author: BIMStone; BIMObjectName: 3810F-105-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - EAN Number: 6414150103162; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; Noise Class: I (ISO 3822) Oras lab.; RSK Number: 8275667; Sales Package dimensions (LxWxH): 540 x 146 x 59; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/3810F-105-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/185192_3810F-105-33_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/3810F-105-33; VVS Number: 701397331
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/3810F-105-33; 3D View: https://static.oras.com/AR/3810F-105-33; Catalog Drawing URL: http://static.oras.com/catdrw/3810F-105-33; Dimension Drawing URL: http://static.oras.com/dimdrw/3810F-105-33; FDV Document URL: http://www.oras.com/datasheet/3810F-105-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3810F-105-33; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/3810F-105-33; Interactive AR View URL: https://static.oras.com/AR/3810F-105-33; Long Marketing: Washbasin faucet with fixed spout and solid lever. There are also in-built limitation options for water temperature and maximum flowrate. F= with flexible pipes; Manufacturer: Oras; Market: International;Sweden;Denmark;Poland; Mobile Product Information URL: http://mpi.oras.com/3810F-105-33; Model: 3810F-105-33 Washbasin faucet; Name_en: 3810F-105-33 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 3810F-105-33; Product Family: Oras Twista Eco; Product Image URL: http://static.oras.com/image/3810F-105-33; Product URL: http://static.oras.com/3810F-105-33; Spare-Part Information URL: http://static.oras.com/sp/3810F-105-33; Technical DataSheet URL: http://www.oras.com/datasheet/3810F-105-33/en; Type Name: 3810F-105-33 Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass - Matt black
Type - Mechanical - Advanced Features: Rapid installation system; Aerator: Standard aerator; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Eco Flow At 300kPa: 0.00243671 m3/s; Flow Rate At 300kPa With Flow Controller: 0.00254266 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 35 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Spout Projection: 121 mm; Spout Type: Fixed spout; Surface treatment: Matt black; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3810F-105-33(2023); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3810F-105-33; Name: 3810F-105-33 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x155x145 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0379877 m2; Volume: 0.00108913 m3
Identity Data - Mark: 27
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 3810F-105-33(2023): 3810F-105-33 Washbasin faucet; Family and Type: 3810F-105-33(2023): 3810F-105-33 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3810F-105-33(2023): 3810F-105-33 Washbasin faucet; Type Id: 3810F-105-33(2023): 3810F-105-33 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
